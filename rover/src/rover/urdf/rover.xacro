Commit message: +added rover change

File: rover/src/rover/urdf/rover.xacro (robot description, xacro)
@@ -43,5 +43,5 @@
         <collision>
             <geometry>
-                <box size="0.8 0.7 0.2"/>
+                <box size="0.8 0.7 0.3"/>
             </geometry>
         </collision>
